v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {opamp_two_stage.sym} 80 -60 0 0 {name=x1}
