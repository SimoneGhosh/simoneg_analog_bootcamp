v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {opamp_two_stage.sym} 180 -150 0 0 {name=x1}
C {devices/vsource.sym} 180 -220 2 0 {name=VDD value=1.8 savecurrent=false}
C {devices/vsource.sym} 180 -80 0 0 {name=VSS value=0 savecurrent=false}
C {devices/gnd.sym} 180 -50 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} 180 -250 2 1 {name=l2 lab=GND}
